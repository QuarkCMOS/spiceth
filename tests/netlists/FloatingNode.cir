
R1 n1 n2 1k

.OP
.END